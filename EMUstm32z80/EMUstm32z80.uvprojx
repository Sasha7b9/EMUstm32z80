# Keil uVision project EMUstm32z80.uvprojx, settings and files
target EMUstm32z80 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EMUstm32z80
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\STM32Cube_FW_F4\Drivers\CMSIS\Include;..\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../STM32Cube_FW_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
    ../STM32Cube_FW_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f437xx.s
    ../STM32Cube_FW_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group src
    ./src/: main.c defines.h RAM.c RAM.h Timer.c Timer.h
  group CPU
    ./src/CPU/: registers.c registers.h DAA.c DAA.h instr.c instr.h instrCB.c instrCB.h instrDD.c instrDD.h instrED.c instrED.h instrFD.c instrFD.h
  group Hardware
    ./src/Hardware/: ports.c ports.h
